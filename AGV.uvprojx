# Keil uVision project AGV.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AGV +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10x_HD_XL,USE_STDPERIPH_DRIVER
  c include: .\board;.\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;.\STM32F10x_library_V35\inc;..\AGVproject
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group cpu
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/: startup_stm32f10x_hd_vl.s
    ./CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group driver
    ./STM32F10x_library_V35/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./STM32F10x_library_V35/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group board
    ./board/: board.h board_config.h board.c tuoluoyi.c tuoluoyi.h camera.c camera.h motor.c motor.h flash.c flash.h
  group app
    ./: app_config.h main.c includes.h public.h stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h public.c agv.c agv.h
